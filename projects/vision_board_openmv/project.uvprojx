# Keil uVision project project.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: R7FA8D1BH Renesas
  pack: Renesas.RA8_DFP.0.0.2
  cpu: IRAM(0x22000000,0xE0000) IRAM2(0x0,0x10000) IROM(0x02000000,0x001F8000) XRAM(0x20000000,0x10000) CPUTYPE("Cortex-M85") FPU3(DFPU) DSP TZ MVE(FP) PACBTI CLOCK(12000000) ELITTLE
  output: rtthread +hex
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3
  c define: __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, ARM_MATH_CM85, NDEBUG, RT_USING_LIBC, MICROPY_PY_DISPLAY = 1, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__, __FPU_PRESENT, MICROPY_PY_SENSOR = 1
  c misc: -Wno-license-management -Wuninitialized -Wall -Wmissing-declarations -Wpointer-arith -Waggregate-return -Wfloat-equal
  c include: board\ports\omv_fs;libraries\HAL_Drivers\config;packages\OpenMV-v4.5.0\src\omv\sensors;rt-thread\components\drivers\include;rt-thread\components\libc\posix\ipc;packages\OpenMV-v4.5.0\src\omv\modules\ulab\code\user;rt-thread\components\net\sal\impl;rt-thread\components\net\lwip\lwip-2.0.3\src\include;rt-thread\components\libc\posix\io\poll;packages\OpenMV-v4.5.0\src\omv\modules;rt-thread\components\libc\compilers\common\extension\fcntl\octal;packages\micropython-v1.13.0\py;packages\OpenMV-v4.5.0\src\omv\modules\ulab\code\numpy\carray;packages\OpenMV-v4.5.0\src\omv\modules\ulab\code\scipy\optimize;board\ports\mipi_lcd;packages\OpenMV-v4.5.0;rt-thread\components\libc\posix\io\eventfd;rt-thread\components\drivers\include;rt-thread\components\finsh;packages\OpenMV-v4.5.0\src\omv\modules\ulab\code;rt-thread\components\net\sal\include\dfs_net;rt-thread\components\drivers\wlan;packages\OpenMV-v4.5.0\src\omv\alloc;packages\CmBacktrace-v1.4.1;rt-thread\libcpu\arm\common;rt-thread\components\fal\inc;rt-thread\components\drivers\spi;packages\micropython-v1.13.0\lib\utils;packages\rw007-v2.1.0\inc;rt-thread\components\dfs\dfs_v1\include;packages\OpenMV-v4.5.0\src\omv\ports\ra8;packages\micropython-v1.13.0\port\modules;packages\OpenMV-v4.5.0\src\omv\modules\ulab\code\numpy\linalg;board\ports;rt-thread\components\net\netdev\include;rt-thread\components\net\sal\include;rt-thread\components\dfs\dfs_v1\filesystems\elmfat;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;packages\OpenMV-v4.5.0\src\lib\libtf;packages\micropython-v1.13.0\lib\libm_dbl;rt-thread\components\net\lwip\port;packages\OpenMV-v4.5.0\src\omv\imlib;packages\OpenMV-v4.5.0\src\omv\modules\ulab\code\numpy\ndarray;rt-thread\components\libc\compilers\common\include;packages\OpenMV-v4.5.0\src\omv\modules\ulab\code\numpy;rt-thread\components\drivers\include;rt-thread\components\libc\posix\io\epoll;rt-thread\components\drivers\include;rt-thread\components\drivers\include;packages\OpenMV-v4.5.0\src\omv\modules\ulab\code\numpy\fft;packages\OpenMV-v4.5.0\src\omv\modules\ulab\code\scipy\signal;packages\OpenMV-v4.5.0\src\omv\modules\ulab\code\utils;rt-thread\components\net\sal\include\socket\sys_socket;packages\micropython-v1.13.0\port\modules\machine;rt-thread\components\libc\compilers\common\extension;rt-thread\components\net\sal\include\socket;rt-thread\components\drivers\include;libraries\HAL_Drivers;packages\OpenMV-v4.5.0\src\omv;packages\OpenMV-v4.5.0\src\omv\common;packages\OpenMV-v4.5.0\src\omv\modules\ulab\code\scipy\special;board\ports\wifi;rt-thread\components\libc\cplusplus;rt-thread\libcpu\arm\cortex-m85;packages\micropython-v1.13.0\ports\renesas;.;packages\rw007-v2.1.0;packages\micropython-v1.13.0;packages\OpenMV-v4.5.0\src\omv\boards\RA8;rt-thread\components\dfs\dfs_v1\filesystems\devfs;rt-thread\components\net\lwip\lwip-2.0.3\src\include\ipv4;packages\OpenMV-v4.5.0\src\hal\cmsis\include;board;board\ports\scc8660;packages\OpenMV-v4.5.0\src\hal;packages\micropython-v1.13.0\ports\renesas\boards\EK-RA8D1;packages\OpenMV-v4.5.0\src\omv\modules\ulab\code\scipy\linalg;rt-thread\include;packages\tinyusb\src;rt-thread\components\drivers\include;packages\tinyusb\lib\rt-thread;packages\micropython-v1.13.0\port;rt-thread\components\net\lwip\lwip-2.0.3\src\include\netif
  library: MicroLIB
  memory RVCT4: ROM 0x2000000 size 0x1f8000
  memory RVCT6: RAM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x22000000 size 0xe0000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: .\script\fsp.scat
  group cm_backtrace
    packages/CmBacktrace-v1.4.1/: cm_backtrace.c cmb_flash_log.c cmb_port.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group CPP
    rt-thread/components/libc/cplusplus/: cxx_crt.cpp cxx_crt_init.c
  group CPU
    rt-thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m85/: context_gcc.S cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/core/: device.c
    rt-thread/components/drivers/hwtimer/: hwtimer.c
    rt-thread/components/drivers/i2c/: i2c-bit-ops.c i2c_core.c i2c_dev.c
    rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: pin.c rt_drv_pwm.c
    rt-thread/components/drivers/mtd/: mtd_nor.c
    rt-thread/components/drivers/rtc/: rtc.c soft_rtc.c
    rt-thread/components/drivers/sdio/: block_dev.c gpt.c mmc.c mmcsd_core.c sd.c sdio.c
    rt-thread/components/drivers/serial/: serial_v2.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c
    rt-thread/components/drivers/wlan/: wlan_cfg.c wlan_cmd.c wlan_dev.c wlan_lwip.c wlan_mgnt.c wlan_prot.c wlan_workqueue.c
  group Drivers
    board/ports/: drv_sdram.c mnt.c
    board/ports/mipi_lcd/: mipi_config.c
    board/ports/wifi/: drv_rw007.c
    board/: ra8_it.c
    libraries/HAL_Drivers/: drv_common.c drv_flash.c drv_gpio.c drv_lcd.c drv_pwm.c drv_sci.c drv_sdhi.c drv_soft_i2c.c drv_spi.c drv_usart_v2.c
  group Fal
    rt-thread/components/fal/src/: fal.c fal_flash.c fal_rtt.c fal_partition.c
  group Filesystem
    rt-thread/components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    rt-thread/components/dfs/dfs_v1/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    rt-thread/components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c msh_file.c
  group Kernel
    rt-thread/src/: clock.c components.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler_up.c thread.c timer.c
  group lwIP
    rt-thread/components/net/lwip/lwip-2.0.3/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/apps/ping/: ping.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/netif/: ethernet.c lowpan6.c
    rt-thread/components/net/lwip/port/: ethernetif.c sys_arch.c
  group micropython
    packages/micropython-v1.13.0/py/: unicode.c sequence.c lexer.c modcmath.c nlrmips.c objfilter.c objreversed.c omvdummy.c stackctrl.c objnone.c modcollections.c bc.c objmap.c moduerrno.c objproperty.c emitnative.c binary.c formatfloat.c nlrsetjmp.c objexcept.c objsingleton.c asmxtensa.c map.c objint_mpz.c objstrunicode.c repl.c asmarm.c emitnxtensa.c nlrx64.c parse.c emitcommon.c modio.c objclosure.c modmicropython.c emitnx64.c objgetitemiter.c nlrxtensa.c parsenum.c vstr.c emitnarm.c asmbase.c modmath.c nlrthumb.c reader.c builtinimport.c objint_longlong.c parsenumbase.c compile.c objgenerator.c objstringio.c scope.c nlrpowerpc.c emitnxtensawin.c objfloat.c stream.c ringbuf.c modthread.c asmthumb.c emitnthumb.c objzip.c builtinhelp.c argcheck.c emitbc.c objfun.c obj.c persistentcode.c objnamedtuple.c scheduler.c malloc.c objcell.c objmodule.c objobject.c showbc.c modsys.c modbuiltins.c objarray.c objattrtuple.c profile.c modarray.c asmx64.c mpprint.c objdict.c opmethods.c objrange.c smallint.c emitglue.c emitinlinethumb.c objbool.c objpolyiter.c runtime.c asmx86.c pairheap.c objtuple.c emitnx86.c nlrx86.c objslice.c pystack.c mpz.c nativeglue.c objenumerate.c qstr.c objboundmeth.c emitinlinextensa.c nlr.c objdeque.c objcomplex.c objstr.c mpstate.c frozenmod.c nlraarch64.c objset.c objtype.c objint.c runtime_utils.c gc.c warning.c vm.c builtinevex.c modstruct.c modgc.c objlist.c
    packages/micropython-v1.13.0/extmod/: machine_mem.c modutimeq.c moduzlib.c moduwebsocket.c machine_pinbase.c machine_spi.c machine_i2c.c modussl_axtls.c modwebrepl.c vfs_fat.c vfs_fat_diskio.c machine_pulse.c moduhashlib.c modussl_mbedtls.c modubinascii.c modwebsocket.c vfs_fat_file.c vfs_posix.c modbtree.c moduheapq.c moduselect.c modonewire.c modujson.c vfs.c modure.c vfs_reader.c machine_signal.c vfs_posix_file.c utime_mphal.c moductypes.c modframebuf.c virtpin.c moducryptolib.c modurandom.c uos_dupterm.c
    packages/micropython-v1.13.0/lib/utils/: mpirq.c sys_stdio_mphal.c interrupt_char.c stdout_helpers.c pyexec.c printf.c
    packages/micropython-v1.13.0/lib/timeutils/: timeutils.c
    packages/micropython-v1.13.0/drivers/bus/: softqspi.c softspi.c
    packages/micropython-v1.13.0/lib/netutils/: netutils.c
    packages/micropython-v1.13.0/lib/mp-readline/: readline.c
  group micropython/machine
    packages/micropython-v1.13.0/port/modules/machine/: machine_rtc.c machine_lcd.c machine_timer.c machine_hw_i2c.c machine_pin.c machine_uart.c machine_hw_spi.c modmachine.c machine_wdt.c machine_pwm.c machine_adc.c
  group micropython/modules
    packages/micropython-v1.13.0/port/native/: easyflash_module.c native_module.c
    packages/micropython-v1.13.0/port/modules/: modrtthread.c modutils.c moduos.c modusocket.c moduos_file.c modfile.c modutime.c modnetwork.c modffi.c modpyb.c modnetwork_wlan.c
    packages/micropython-v1.13.0/port/: mpgetcharport.c mpthreadport.c frozen_mpy.c mpputsnport.c gccollect.c mpy_main.c mphalport.c
    packages/micropython-v1.13.0/port/modules/user/: moduserfunc.c
  group micropython/ra-port
    packages/micropython-v1.13.0/ports/renesas/: pyb_i2c.c pyb_uart.c led.c tinyusb_debug.c bufhelper.c machine_led.c
  group openmv/alloc
    packages/OpenMV-v4.5.0/src/omv/alloc/: fb_alloc.c xalloc.c dma_alloc.c umm_malloc.c unaligned_memcpy.c
  group openmv/common
    packages/OpenMV-v4.5.0/src/omv/common/: vospi.c factoryreset.c usbdbg.c trace.c mutex.c sensor_utils.c ringbuf.c array.c
  group openmv/dsp
    packages/OpenMV-v4.5.0/src/hal/cmsis/src/dsp/FastMathFunctions/: arm_cos_f32.c arm_sin_f32.c arm_sin_q31.c arm_cos_q31.c arm_sin_q15.c arm_cos_q15.c arm_sqrt_q15.c arm_sqrt_q31.c
    packages/OpenMV-v4.5.0/src/hal/cmsis/src/dsp/CommonTables/: arm_common_tables.c arm_const_structs.c
    packages/OpenMV-v4.5.0/src/hal/cmsis/src/dsp/TransformFunctions/: arm_rfft_init_q15.c arm_rfft_init_q31.c
  group openmv/imlib
    packages/OpenMV-v4.5.0/src/omv/imlib/: yuv.c mathop.c blob.c orb.c fast.c rainbow_tab.c hough.c qsort.c fsort.c collections.c eye.c line.c gif.c stereo.c lodepng.c imlib.c font.c bmp.c lab_tab.c lbp.c isp.c rectangle.c mjpeg.c fft.c jpeg.c draw.c integral_mw.c integral.c bayer.c selective_search.c point.c qrcode.c framebuffer.c clahe.c edge.c png.c hog.c zbar.c haar.c phasecorrelation.c filter.c pool.c template.c stats.c kmeans.c lsd.c apriltag.c dmtx.c sincos_tab.c xyz_tab.c binary.c ppm.c agast.c fmath.c jpegd.c
  group openmv/modules
    packages/OpenMV-v4.5.0/src/omv/modules/: py_spi_display.c py_gif.c py_display.c py_clock.c py_mjpeg.c py_helper.c py_omv.c py_imageio.c py_sensor.c py_image.c
  group openmv/port/ra8
    packages/OpenMV-v4.5.0/src/omv/ports/ra8/: cambus.c sensor.c omv_lcd.c omv_gpio.c
  group openmv/rtt-port
    board/ports/omv_fs/: ff_wrapper.c
  group openmv/sensor
    packages/OpenMV-v4.5.0/src/omv/sensors/: lepton.c paj6100.c ov7725.c gc2145.c ov7670.c mt9m114.c gc0328.c ov5640.c hm0360.c ov9650.c ov2640.c scc8660.c frogeye2020.c mt9v0xx.c hm01b0.c ov7690.c
  group openmv/ulab
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/: ndarray_properties.c ndarray_operators.c ulab_tools.c ndarray.c ulab.c
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/utils/: utils.c
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/numpy/: numerical.c vector.c numpy.c create.c stats.c compare.c transform.c poly.c filter.c approx.c
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/numpy/linalg/: linalg_tools.c linalg.c
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/numpy/ndarray/: ndarray_iter.c
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/numpy/fft/: fft_tools.c fft.c
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/numpy/carray/: carray.c carray_tools.c
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/user/: user.c
  group openmv/ulab/scipy
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/scipy/: scipy.c
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/scipy/optimize/: optimize.c
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/scipy/signal/: signal.c
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/scipy/special/: special.c
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/scipy/linalg/: linalg.c
  group POSIX
    rt-thread/components/libc/posix/io/poll/: poll.c select.c
  group rw007
    packages/rw007-v2.1.0/src/: spi_wifi_rw007.c
  group SAL
    rt-thread/components/net/netdev/src/: netdev.c netdev_ipaddr.c
    rt-thread/components/net/sal/dfs_net/: dfs_net.c
    rt-thread/components/net/sal/impl/: af_inet_lwip.c
    rt-thread/components/net/sal/socket/: net_netdb.c net_sockets.c
    rt-thread/components/net/sal/src/: sal_socket.c
  group TinyUSB
    board/tinyusb/: drv_tinyusb.c
    packages/tinyusb/src/class/cdc/: cdc_device.c
    packages/tinyusb/src/class/msc/: msc_device.c
    packages/tinyusb/src/common/: tusb_fifo.c
    packages/tinyusb/src/device/: usbd.c usbd_control.c
    packages/tinyusb/src/portable/renesas/rusb2/: dcd_rusb2.c rusb2_common.c
    packages/tinyusb/src/: tusb.c
    packages/tinyusb/lib/rt-thread/port/: msc_device_port.c
    packages/tinyusb/lib/rt-thread/: tinyusb_port.c usb_descriptors.c
  group WICED
    board/ports/scc8660/: scc8660.lib
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c
software components: Flex Software:RA Configuration 1.0.0
