# Keil uVision project project.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: R7FA8D1BH Renesas
  pack: Renesas.RA8_DFP.0.0.2
  cpu: IRAM(0x22000000,0xE0000) IRAM2(0x0,0x10000) IROM(0x02000000,0x001F8000) XRAM(0x20000000,0x10000) CPUTYPE("Cortex-M85") FPU3(DFPU) DSP TZ MVE(FP) PACBTI CLOCK(12000000) ELITTLE
  output: rtthread +hex
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3
  c define: __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, NDEBUG, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__, MICROPY_PY_SENSOR = 1
  c misc: -Wno-license-management -Wuninitialized -Wall -Wmissing-declarations -Wpointer-arith -Waggregate-return -Wfloat-equal
  c include: board;libraries\components\micropython\shared\readline;rt-thread\components\libc\compilers\common\include;rt-thread\components\dfs\dfs_v1\include;rt-thread\components\dfs\dfs_v1\filesystems\devfs;rt-thread\libcpu\arm\cortex-m85;board\ports;rt-thread\components\libc\posix\ipc;libraries\components\micropython\py;rt-thread\components\drivers\include;libraries\components\micropython\extmod;rt-thread\components\libc\compilers\common\extension\fcntl\octal;rt-thread\components\libc\posix\io\epoll;rt-thread\libcpu\arm\common;libraries\components\micropython;board\ports\mpy_port;.;board\ports\mpy_port\renesas-ra;rt-thread\components\libc\posix\io\poll;libraries\HAL_Drivers\config;rt-thread\components\drivers\include;rt-thread\components\finsh;board\ports\mpy_port\port\rtthread_port;board\ports\mpy_port\port;libraries\HAL_Drivers;libraries\components\micropython\lib\uzlib;rt-thread\components\drivers\include;rt-thread\components\drivers\include;libraries\components\micropython\shared\runtime;rt-thread\components\libc\posix\io\eventfd;rt-thread\components\libc\compilers\common\extension;rt-thread\include
  memory RVCT4: ROM 0x2000000 size 0x1f8000
  memory RVCT6: RAM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x22000000 size 0xe0000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: .\script\fsp.scat
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group CPU
    rt-thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m85/: context_gcc.S cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/core/: device.c
    rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/serial/: serial_v2.c
  group Drivers
    board/ports/: drv_sdram.c mnt.c
    board/: ra8_it.c
    libraries/HAL_Drivers/: drv_common.c drv_gpio.c drv_usart_v2.c
  group Filesystem
    rt-thread/components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    rt-thread/components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c msh_file.c
  group Kernel
    rt-thread/src/: clock.c components.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler_up.c thread.c timer.c
  group micropython
    libraries/components/micropython/py/: objnamedtuple.c vstr.c asmx86.c emitbc.c nlrxtensa.c objreversed.c parsenum.c lexer.c binary.c objproperty.c objnone.c argcheck.c nlrsetjmp.c objclosure.c parse.c objint_mpz.c emitnxtensa.c builtinhelp.c objint_longlong.c warning.c builtinimport.c nlrx64.c objcomplex.c objdict.c objenumerate.c modgc.c map.c objset.c stackctrl.c formatfloat.c compile.c objfun.c objstr.c objzip.c modmath.c emitnthumb.c persistentcode.c qstr.c asmxtensa.c moderrno.c profile.c objtype.c sequence.c modstruct.c modarray.c objsingleton.c scheduler.c emitinlinethumb.c nlraarch64.c objpolyiter.c objstringio.c showbc.c nativeglue.c objgetitemiter.c unicode.c asmbase.c modmicropython.c objrange.c pairheap.c vm.c nlrpowerpc.c modsys.c nlrthumb.c opmethods.c objslice.c emitnative.c malloc.c parsenumbase.c nlrx86.c gc.c obj.c objdeque.c pystack.c emitnxtensawin.c emitglue.c objmap.c frozenmod.c mpprint.c objarray.c objlist.c objgenerator.c modbuiltins.c nlr.c objfloat.c ringbuf.c emitinlinextensa.c mpstate.c objattrtuple.c objtuple.c objstrunicode.c emitnarm.c modio.c runtime.c smallint.c emitnx86.c nlrmips.c objbool.c reader.c objexcept.c modcollections.c asmx64.c objfilter.c objobject.c mpz.c emitnx64.c objboundmeth.c repl.c scope.c builtinevex.c asmthumb.c objint.c stream.c asmarm.c modcmath.c objcell.c runtime_utils.c objmodule.c emitcommon.c bc.c
  group micropython/extmod
    libraries/components/micropython/extmod/: modre.c modcryptolib.c moductypes.c modheapq.c modtime.c moddeflate.c modos.c modselect.c modhashlib.c modplatform.c modasyncio.c modrandom.c modbinascii.c modjson.c
  group micropython/lib
    libraries/components/micropython/lib/uzlib/: crc32.c tinflate.c header.c lz77.c adler32.c
  group micropython/port
    board/ports/mpy_port/port/: _frozen_mpy.c mpy_main.c mphalport.c
    board/ports/mpy_port/port/rtthread_port/: mpputsnport.c mpthreadport.c modfile.c mpgetcharport.c
    board/ports/mpy_port/renesas-ra/: irq.c
  group micropython/share
    libraries/components/micropython/shared/runtime/: sys_stdio_mphal.c gchelper_thumb2.s gchelper_native.c mpirq.c pyexec.c stdout_helpers.c semihosting.c interrupt_char.c
    libraries/components/micropython/shared/readline/: readline.c
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c
software components: Flex Software:RA Configuration 1.0.0
